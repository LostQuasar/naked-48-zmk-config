## boards/shields/naked48/Kconfig.defconfig
```kconfig
if SHIELD_NAKED48

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "Naked48"

endif
```
